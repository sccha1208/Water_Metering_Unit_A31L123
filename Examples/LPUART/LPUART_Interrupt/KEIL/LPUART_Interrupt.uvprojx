# Keil uVision project LPUART_Interrupt.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPUART_Interrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\ABOV\A31L12x\Include;..\..\..\..\Drivers\Include;..\..\..\..\Examples\LPUART\LPUART_Interrupt
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Device
    ../../../../Core/Device/ABOV/A31L12x/Source/: system_A31L12x.c
  group Main
    ../../../../Examples/LPUART/LPUART_Interrupt/: A31L12x_it.c A31L12x_PortInit.c A31L12x_SystemClock.c main.c
    ../: main_conf.h meter_protocol.h meter_protocol.c
  group Startup
    ../../../../Core/Device/ABOV/A31L12x/Source/ARM/: startup_A31L12x.s
  group Option
    ../../../../Option/KEIL/: option_A31L12x.s
  group Drivers
    ../../../../Drivers/Source/: A31L12x_hal_intc.c A31L12x_hal_lpuart.c A31L12x_hal_pcu.c A31L12x_hal_scu.c A31L12x_hal_uartn.c A31L12x_hal_debug_frmwrk.c
software components: CMSIS:CORE 5.1.1
