# IAR project LPUART_Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31L123 ABOV A31L123
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\ABOV\A31L12x\Include; ..\..\..\..\Drivers\Include; ..\..\..\..\Examples\LPUART\LPUART_Interrupt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPUART_Interrupt.hex
  ILINK.IlinkOutputFile: LPUART_Interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Device
    ../../../../Core/Device/ABOV/A31L12x/Source/: system_A31L12x.c
  group Drivers
    ../../../../Drivers/Source/: A31L12x_hal_intc.c A31L12x_hal_lpuart.c A31L12x_hal_pcu.c A31L12x_hal_scu.c A31L12x_hal_uartn.c A31L12x_hal_debug_frmwrk.c
  group Main
    ../../../../Examples/LPUART/LPUART_Interrupt/: A31L12x_it.c A31L12x_PortInit.c A31L12x_SystemClock.c main.c
  group Option
    ../../../../Option/IAR/: option_A31L12x_iar.c
  group Startup
    ../../../../Core/Device/ABOV/A31L12x/Source/IAR/: startup_A31L12x_iar.s
