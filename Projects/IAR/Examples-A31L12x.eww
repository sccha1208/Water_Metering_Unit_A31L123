<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\Examples\ADC\ADC_ContinuousMode\IAR\ADC_ContinuousMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\ADC\ADC_SequentialMode\IAR\ADC_SequentialMode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\ADC\ADC_SingleMode_Interrupt\IAR\ADC_SingleMode_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\ADC\ADC_SingleMode_Polling\IAR\ADC_SingleMode_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\CMPn\CMPn_Test\IAR\CMPn_Test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\CRC\CRC_Checksum\IAR\CRC_Checksum.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\CRC\CRC_CRC8\IAR\CRC_CRC8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\CRC\CRC_CRC16\IAR\CRC_CRC16.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\CRC\CRC_CRC16_CCITT\IAR\CRC_CRC16_CCITT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\CRC\CRC_CRC32\IAR\CRC_CRC32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_ADC\IAR\DMACn_ADC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_I2Cn\IAR\DMACn_I2Cn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_LPUART\IAR\DMACn_LPUART.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_SCn_SCI\IAR\DMACn_SCn_SCI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_SCn_UART\IAR\DMACn_SCn_UART.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_SPIn\IAR\DMACn_SPIn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_UARTn\IAR\DMACn_UARTn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\DMACn\DMACn_USART1n_UART\IAR\DMACn_USART1n_UART.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\FMC\FMC_Flash\IAR\FMC_Flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\GPIO\GPIO_EINT\IAR\GPIO_EINT.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\GPIO\GPIO_Input\IAR\GPIO_Input.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\GPIO\GPIO_LEDBlinky\IAR\GPIO_LEDBlinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\I2Cn\I2Cn_MasterSlave\IAR\I2Cn_MasterSlave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\LCD\LCD_Test\IAR\LCD_Test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\LPUART\LPUART_Interrupt\IAR\LPUART_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\LPUART\LPUART_Polling\IAR\LPUART_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\PMU\PMU_AllPowerOff\IAR\PMU_AllPowerOff.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\PMU\PMU_SRAMRetentionPower\IAR\PMU_SRAMRetentionPower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\PWR\PWR_DeepSleep\IAR\PWR_DeepSleep.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\PWR\PWR_LVI_Interrupt\IAR\PWR_LVI_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\PWR\PWR_LVI_Polling\IAR\PWR_LVI_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\PWR\PWR_Sleep\IAR\PWR_Sleep.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\RTCC\RTCC_Test\IAR\RTCC_Test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\SCn\SCn_SCI_Interrupt\IAR\SCn_SCI_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\SCn\SCn_SCI_Polling\IAR\SCn_SCI_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\SCn\SCn_UART_Interrupt\IAR\SCn_UART_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\SCn\SCn_UART_Polling\IAR\SCn_UART_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\SPIn\SPIn_Interrupt\IAR\SPIn_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\SPIn\SPIn_Polling\IAR\SPIn_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER4n\TIMER4n_BackToBack\IAR\TIMER4n_BackToBack.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER4n\TIMER4n_Capture\IAR\TIMER4n_Capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER4n\TIMER4n_CounterSharing\IAR\TIMER4n_CounterSharing.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER4n\TIMER4n_OneShot\IAR\TIMER4n_OneShot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER4n\TIMER4n_PeriodMatchInterrupt\IAR\TIMER4n_PeriodMatchInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER4n\TIMER4n_PeriodMatchPolling\IAR\TIMER4n_PeriodMatchPolling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER5n\TIMER5n_Capture\IAR\TIMER5n_Capture.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER5n\TIMER5n_MatchInterrupt\IAR\TIMER5n_MatchInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER5n\TIMER5n_MatchPolling\IAR\TIMER5n_MatchPolling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER5n\TIMER5n_OneShot\IAR\TIMER5n_OneShot.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\TIMER5n\TIMER5n_PWM\IAR\TIMER5n_PWM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\UARTn\UARTn_Interrupt\IAR\UARTn_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\UARTn\UARTn_Polling\IAR\UARTn_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\USART1n\USART1n_SPI_Interrupt\IAR\USART1n_SPI_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\USART1n\USART1n_SPI_Polling\IAR\USART1n_SPI_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\USART1n\USART1n_UART_Interrupt\IAR\USART1n_UART_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\USART1n\USART1n_UART_Polling\IAR\USART1n_UART_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\USART1n\USART1n_USRT_Interrupt\IAR\USART1n_USRT_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\USART1n\USART1n_USRT_Polling\IAR\USART1n_USRT_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\WDT\WDT_Interrupt\IAR\WDT_Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\WDT\WDT_Polling\IAR\WDT_Polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\Examples\WDT\WDT_Reset\IAR\WDT_Reset.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>ADC_ContinuousMode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ADC_SequentialMode</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ADC_SingleMode_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ADC_SingleMode_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CMPn_Test</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CRC_Checksum</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CRC_CRC8</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CRC_CRC16</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CRC_CRC16_CCITT</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CRC_CRC32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_ADC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_I2Cn</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_LPUART</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_SCn_SCI</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_SCn_UART</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_SPIn</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_UARTn</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMACn_USART1n_UART</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>FMC_Flash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>GPIO_EINT</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>GPIO_Input</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>GPIO_LEDBlinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>I2Cn_MasterSlave</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>LCD_Test</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>LPUART_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>LPUART_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PMU_AllPowerOff</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PMU_SRAMRetentionPower</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWR_DeepSleep</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWR_LVI_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWR_LVI_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PWR_Sleep</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RTCC_Test</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SCn_SCI_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SCn_SCI_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SCn_UART_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SCn_UART_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SPIn_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SPIn_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER4n_BackToBack</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER4n_Capture</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER4n_CounterSharing</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER4n_OneShot</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER4n_PeriodMatchInterrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER4n_PeriodMatchPolling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER5n_Capture</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER5n_MatchInterrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER5n_MatchPolling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER5n_OneShot</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>TIMER5n_PWM</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UARTn_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UARTn_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USART1n_SPI_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USART1n_SPI_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USART1n_UART_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USART1n_UART_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USART1n_USRT_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USART1n_USRT_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>WDT_Interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>WDT_Polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>WDT_Reset</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


